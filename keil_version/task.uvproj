# Keil uVision project task.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: task +hex
  c flags: Optimize=8 SizeSpeed=1
  group screens
    ./src/screens/: alartScreen.c mainScreen.c settingScreen.c startupScreen.c alartScreen.h mainScreen.h settingScreen.h startupScreen.h
  group utils
    ./src/utils/: AT24C02.c AT24C02.h BEEP.c BEEP.h DELAY.c DELAY.h DS18B20.c DS18B20.h FUNCTIONS.c FUNCTIONS.h IIC.c IIC.h LCD1602.c LCD1602.h FAN_PWM.c FAN_PWM.h
  group app
    ./src/: main.c
