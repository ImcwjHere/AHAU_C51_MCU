# Keil uVision project Task.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Task +hex
  c flags: Optimize=8 SizeSpeed=1
  group screens
    ../eide/src/screens/: alartScreen.c alartScreen.h mainScreen.c mainScreen.h settingScreen.c settingScreen.h startupScreen.c startupScreen.h
  group utils
    ../eide/src/utils/: AT24C02.c AT24C02.h BEEP.c BEEP.h DELAY.c DELAY.h DS18B20.c DS18B20.h FAN_PWM.c FAN_PWM.h FUNCTIONS.c FUNCTIONS.h IIC.c IIC.h LCD1602.c LCD1602.h
  group app
    ../eide/src/: CONFIGS.h main.c
